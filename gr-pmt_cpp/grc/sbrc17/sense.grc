<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>spectrum_sensing</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>spectrum_sensing</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>File_Recorder</key>
<param><key>id</key><value>File_Recorder_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>sense_tune_command</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>file_ready</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>sense_data</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>sense</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pmt_cpp_file_connect</key>
<param><key>id</key><value>pmt_cpp_file_connect_0</value></param>
</block>
<block>
<key>pmt_cpp_send_file_ACK</key>
<param><key>id</key><value>pmt_cpp_send_file_ACK_0</value></param>
</block>
<block>
<key>pmt_cpp_start_sense</key>
<param><key>id</key><value>pmt_cpp_start_sense_0</value></param>
</block>
<connection><source_block_id>File_Recorder_0</source_block_id><sink_block_id>pmt_cpp_send_file_ACK_0</sink_block_id><source_key>file_ready</source_key><sink_key>file_ready</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>pmt_cpp_file_connect_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>pmt_cpp_start_sense_0</sink_block_id><source_key>out</source_key><sink_key>pmt::dict</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0</source_block_id><sink_block_id>File_Recorder_0</sink_block_id><source_key>bool</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0</source_block_id><sink_block_id>File_Recorder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pmt_cpp_send_file_ACK_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_sense_0</source_block_id><sink_block_id>File_Recorder_0</sink_block_id><source_key>bool</source_key><sink_key>bool</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_sense_0</source_block_id><sink_block_id>pmt_cpp_file_connect_0</sink_block_id><source_key>bool</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_sense_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>pmt::mp</source_key><sink_key>in</sink_key></connection>
</flow_graph>
