<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>spectrum_sensing_M</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>spectrum_sensing_M</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>ack_repeat</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>rna_file</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>tuned</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>ok</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>data_sensing</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pmt_cpp_data_extract_master</key>
<param><key>id</key><value>pmt_cpp_data_extract_master_0</value></param>
<param><key>filename</key><value>/tmp/res_sense.txt</value></param>
</block>
<block>
<key>pmt_cpp_preprocessor_master</key>
<param><key>id</key><value>pmt_cpp_preprocessor_master_0</value></param>
</block>
<block>
<key>pmt_cpp_time</key>
<param><key>id</key><value>pmt_cpp_time_0</value></param>
</block>
<block>
<key>pmt_cpp_timer</key>
<param><key>id</key><value>pmt_cpp_timer_0</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>pmt_cpp_data_extract_master_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>pmt_cpp_time_0</sink_block_id><source_key>out</source_key><sink_key>Ack</sink_key></connection>
<connection><source_block_id>pmt_cpp_preprocessor_master_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>rna_file</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_preprocessor_master_0</source_block_id><sink_block_id>pmt_cpp_timer_0</sink_block_id><source_key>rna_file</source_key><sink_key>in2</sink_key></connection>
<connection><source_block_id>pmt_cpp_preprocessor_master_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>tuned</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_time_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>Ack_repeat</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_time_0</source_block_id><sink_block_id>pmt_cpp_time_0</sink_block_id><source_key>Feed_back</source_key><sink_key>Ack</sink_key></connection>
<connection><source_block_id>pmt_cpp_time_0</source_block_id><sink_block_id>pmt_cpp_preprocessor_master_0</sink_block_id><source_key>id_neighbor</source_key><sink_key>id_neighbor</sink_key></connection>
<connection><source_block_id>pmt_cpp_time_0</source_block_id><sink_block_id>pmt_cpp_timer_0</sink_block_id><source_key>id_neighbor</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_timer_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
