<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>spectrum_sharing</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>spectrum_sharing</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>new_freq</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>bool</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>sharing_message</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pmt_cpp_start_share</key>
<param><key>id</key><value>pmt_cpp_start_share_0</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>pmt_cpp_start_share_0</sink_block_id><source_key>out</source_key><sink_key>pmt::dict</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_share_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>bool</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_share_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>pmt::mp</source_key><sink_key>in</sink_key></connection>
</flow_graph>
