<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>master</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>IEEE 802.15.4 Transceiver using OQPSK PHY</value></param>
</block>
<block>
<key>IEEE_802_15_4</key>
<param><key>id</key><value>IEEE_802_15_4_0</value></param>
</block>
<block>
<key>pmt_cpp_HMM</key>
<param><key>id</key><value>pmt_cpp_HMM_0</value></param>
</block>
<block>
<key>pmt_cpp_RandomForest</key>
<param><key>id</key><value>pmt_cpp_RandomForest_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>pmt_cpp_ahp</key>
<param><key>id</key><value>pmt_cpp_ahp_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>pmt_cpp_annp</key>
<param><key>id</key><value>pmt_cpp_annp_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>pmt_cpp_cogmac</key>
<param><key>id</key><value>pmt_cpp_cogmac_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>pmt_cpp_data_extract_master</key>
<param><key>id</key><value>pmt_cpp_data_extract_master_0</value></param>
<param><key>filename</key><value>/tmp/res_sense.txt</value></param>
</block>
<block>
<key>pmt_cpp_message_generation</key>
<param><key>id</key><value>pmt_cpp_message_generation_0</value></param>
</block>
<block>
<key>pmt_cpp_pmt_extract_master</key>
<param><key>id</key><value>pmt_cpp_pmt_extract_master_0</value></param>
</block>
<block>
<key>pmt_cpp_preprocessor_master</key>
<param><key>id</key><value>pmt_cpp_preprocessor_master_0</value></param>
</block>
<block>
<key>pmt_cpp_set_ccc_master</key>
<param><key>id</key><value>pmt_cpp_set_ccc_master_0</value></param>
</block>
<block>
<key>pmt_cpp_set_new_config_master</key>
<param><key>id</key><value>pmt_cpp_set_new_config_master_0</value></param>
</block>
<block>
<key>pmt_cpp_time</key>
<param><key>id</key><value>pmt_cpp_time_0</value></param>
</block>
<block>
<key>pmt_cpp_time_transmission_cycle</key>
<param><key>id</key><value>pmt_cpp_time_transmission_cycle_0</value></param>
</block>
<block>
<key>pmt_cpp_timer</key>
<param><key>id</key><value>pmt_cpp_timer_0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>1000e3</value></param>
<param><key>center_freq0</key><value>6000000000</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>89</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>1000e3</value></param>
<param><key>center_freq0</key><value>6000000000</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>IEEE_802_15_4_0</source_block_id><sink_block_id>pmt_cpp_pmt_extract_master_0</sink_block_id><source_key>rxout</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>IEEE_802_15_4_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pmt_cpp_HMM_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_RandomForest_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_ahp_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_annp_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_cogmac_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_message_generation_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>mp</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_message_generation_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>mp</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_message_generation_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract_master_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>Ack</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract_master_0</source_block_id><sink_block_id>pmt_cpp_data_extract_master_0</sink_block_id><source_key>data</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract_master_0</source_block_id><sink_block_id>pmt_cpp_time_0</sink_block_id><source_key>data</source_key><sink_key>Ack</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract_master_0</source_block_id><sink_block_id>pmt_cpp_set_ccc_master_0</sink_block_id><source_key>freq</source_key><sink_key>flag</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract_master_0</source_block_id><sink_block_id>pmt_cpp_time_transmission_cycle_0</sink_block_id><source_key>freq</source_key><sink_key>in_signal</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract_master_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>freq</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract_master_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>freq</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract_master_0</source_block_id><sink_block_id>pmt_cpp_set_ccc_master_0</sink_block_id><source_key>share</source_key><sink_key>flag</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract_master_0</source_block_id><sink_block_id>pmt_cpp_set_new_config_master_0</sink_block_id><source_key>share</source_key><sink_key>pmt::dict</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract_master_0</source_block_id><sink_block_id>pmt_cpp_time_transmission_cycle_0</sink_block_id><source_key>share</source_key><sink_key>in_signal</sink_key></connection>
<connection><source_block_id>pmt_cpp_preprocessor_master_0</source_block_id><sink_block_id>pmt_cpp_RandomForest_0</sink_block_id><source_key>rna_file</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_preprocessor_master_0</source_block_id><sink_block_id>pmt_cpp_annp_0</sink_block_id><source_key>rna_file</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_preprocessor_master_0</source_block_id><sink_block_id>pmt_cpp_timer_0</sink_block_id><source_key>rna_file</source_key><sink_key>in2</sink_key></connection>
<connection><source_block_id>pmt_cpp_preprocessor_master_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>tuned</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_set_ccc_master_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>ccc</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_set_ccc_master_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>ccc</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_set_ccc_master_0</source_block_id><sink_block_id>pmt_cpp_message_generation_0</sink_block_id><source_key>signal</source_key><sink_key>signal</sink_key></connection>
<connection><source_block_id>pmt_cpp_set_new_config_master_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>bool</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_set_new_config_master_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>pmt::mp</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_set_new_config_master_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>pmt::mp</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_time_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>Ack_repeat</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_time_0</source_block_id><sink_block_id>pmt_cpp_time_0</sink_block_id><source_key>Feed_back</source_key><sink_key>Ack</sink_key></connection>
<connection><source_block_id>pmt_cpp_time_0</source_block_id><sink_block_id>pmt_cpp_preprocessor_master_0</sink_block_id><source_key>id_neighbor</source_key><sink_key>id_neighbor</sink_key></connection>
<connection><source_block_id>pmt_cpp_time_0</source_block_id><sink_block_id>pmt_cpp_timer_0</sink_block_id><source_key>id_neighbor</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_time_transmission_cycle_0</source_block_id><sink_block_id>pmt_cpp_message_generation_0</sink_block_id><source_key>out_signal</source_key><sink_key>signal</sink_key></connection>
<connection><source_block_id>pmt_cpp_time_transmission_cycle_0</source_block_id><sink_block_id>pmt_cpp_set_ccc_master_0</sink_block_id><source_key>out_signal</source_key><sink_key>flag</sink_key></connection>
<connection><source_block_id>pmt_cpp_timer_0</source_block_id><sink_block_id>pmt_cpp_HMM_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_timer_0</source_block_id><sink_block_id>pmt_cpp_RandomForest_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_timer_0</source_block_id><sink_block_id>pmt_cpp_ahp_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_timer_0</source_block_id><sink_block_id>pmt_cpp_cogmac_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
