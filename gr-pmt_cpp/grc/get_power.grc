<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Get_Power</value></param>
<param><key>author</key><value>Ariel</value></param>
<param><key>category</key><value>pmt_cpp</value></param>
<param><key>description</key><value>Para transmissao de pacotes</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Get Power</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>samplehistory</key><value>64</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_trigger_sample_timer</key>
<param><key>id</key><value>es_trigger_sample_timer_0</value></param>
<param><key>length</key><value>512</value></param>
<param><key>period</key><value>200000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>1024</value></param>
<param><key>sched_dist</key><value>200000</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>in_pdu</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pmt_cpp_PDU_json</key>
<param><key>id</key><value>pmt_cpp_PDU_json_0</value></param>
<param><key>filename</key><value>/tmp/power.txt</value></param>
</block>
<block>
<key>pmt_cpp_PDU_remove_all_tags</key>
<param><key>id</key><value>pmt_cpp_PDU_remove_all_tags_0</value></param>
</block>
<block>
<key>pmt_cpp_file_connect</key>
<param><key>id</key><value>pmt_cpp_file_connect_0_0</value></param>
</block>
<block>
<key>uhdgps_cpdu_average_power</key>
<param><key>id</key><value>uhdgps_cpdu_average_power_0</value></param>
<param><key>k</key><value>-60</value></param>
</block>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>uhdgps_cpdu_average_power_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>sample_timer_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>pmt_cpp_file_connect_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>pmt_cpp_PDU_json_0</sink_block_id><source_key>out</source_key><sink_key>bool</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>pmt_cpp_file_connect_0_0</sink_block_id><source_key>out</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>pmt_cpp_PDU_remove_all_tags_0</source_block_id><sink_block_id>pmt_cpp_PDU_json_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0_0</source_block_id><sink_block_id>pmt_cpp_PDU_remove_all_tags_0</sink_block_id><source_key>bool</source_key><sink_key>bool</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0_0</source_block_id><sink_block_id>es_trigger_sample_timer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhdgps_cpdu_average_power_0</source_block_id><sink_block_id>pmt_cpp_PDU_remove_all_tags_0</sink_block_id><source_key>cpdus</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
