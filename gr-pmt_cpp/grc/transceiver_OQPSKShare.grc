<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transceiver_OQPSK</value></param>
<param><key>title</key><value>IEEE 802.15.4 Transceiver using OQPSK PHY</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>you can connect to the Socket PDU with: 'nc -u localhost 52002'</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>50</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>ieee802_15_4_oqpsk_phy</key>
<param><key>id</key><value>ieee802_15_4_oqpsk_phy_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>ieee802_15_4_mac</key>
<param><key>id</key><value>ieee802_15_4_mac_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>ieee802_15_4_rime_stack</key>
<param><key>id</key><value>ieee802_15_4_rime_stack_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>bc_channels</key><value>[129]</value></param>
<param><key>uc_channels</key><value>[131]</value></param>
<param><key>ruc_channels</key><value>[132]</value></param>
<param><key>rime_add</key><value>[23,42]</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
<param><key>host</key><value></value></param>
<param><key>port</key><value>52001</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
</block>
<block>
<key>foo_periodic_msg_source</key>
<param><key>id</key><value>foo_periodic_msg_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>msg</key><value>pmt.intern("&lt;1:2:2,4:2,5&gt;")</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>quit</key><value>False</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>num</key><value>400</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>pmt_cpp_send_file_ACK</key>
<param><key>id</key><value>pmt_cpp_send_file_ACK_1</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>cog_802_15_4</key>
<param><key>id</key><value>cog_802_15_4_0</value></param>
</block>
<block>
<key>pmt_cpp_send_file_ACK</key>
<param><key>id</key><value>pmt_cpp_send_file_ACK_0</value></param>
</block>
<block>
<key>pmt_cpp_pmt_extract2</key>
<param><key>id</key><value>pmt_cpp_pmt_extract2_0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>2480000000</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>ant0</key><value>RX2</value></param>
</block>
<block>
<key>pmt_cpp_start_sense</key>
<param><key>id</key><value>pmt_cpp_start_sense_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>pmt_cpp_send_file</key>
<param><key>id</key><value>pmt_cpp_send_file_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>json_file</key>
<param><key>id</key><value>json_file_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>pmt_cpp_file_connect</key>
<param><key>id</key><value>pmt_cpp_file_connect_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>2480000000</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>pmt_cpp_start_share</key>
<param><key>id</key><value>pmt_cpp_start_share_0</value></param>
</block>
<connection><source_block_id>ieee802_15_4_rime_stack_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>bcout</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>app out</source_key><sink_key>fromMAC</sink_key></connection>
<connection><source_block_id>ieee802_15_4_rime_stack_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>toMAC</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>pdu out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>pdus</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>foo_periodic_msg_source_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>out</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract2_0</source_block_id><sink_block_id>pmt_cpp_start_sense_0</sink_block_id><source_key>pmt_dict</source_key><sink_key>pmt::dict</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>rxout</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0</source_block_id><sink_block_id>json_file_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0</source_block_id><sink_block_id>json_file_0</sink_block_id><source_key>bool</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>pmt_cpp_file_connect_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_sense_0</source_block_id><sink_block_id>json_file_0</sink_block_id><source_key>bool</source_key><sink_key>bool</sink_key></connection>
<connection><source_block_id>pmt_cpp_send_file_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>pdu</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>pmt_cpp_pmt_extract2_0</sink_block_id><source_key>pdu out</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>cog_802_15_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cog_802_15_4_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_periodic_msg_source_0</source_block_id><sink_block_id>cog_802_15_4_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>json_file_0</source_block_id><sink_block_id>pmt_cpp_send_file_0</sink_block_id><source_key>file_ready</source_key><sink_key>file_ready</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rxout</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rxout</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>cog_802_15_4_0</source_block_id><sink_block_id>pmt_cpp_pmt_extract2_0</sink_block_id><source_key>rxout</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>pmt_cpp_send_file_0</source_block_id><sink_block_id>cog_802_15_4_0</sink_block_id><source_key>pdu</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_sense_0</source_block_id><sink_block_id>pmt_cpp_file_connect_0</sink_block_id><source_key>bool</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>cog_802_15_4_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rxout</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_sense_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>pmt::mp</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_sense_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>pmt::mp</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>json_file_0</source_block_id><sink_block_id>pmt_cpp_send_file_ACK_1</sink_block_id><source_key>file_ready</source_key><sink_key>file_ready</sink_key></connection>
<connection><source_block_id>pmt_cpp_send_file_ACK_1</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>pdu</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>pmt_cpp_send_file_ACK_1</source_block_id><sink_block_id>cog_802_15_4_0</sink_block_id><source_key>pdu</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>cog_802_15_4_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>rxout</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract2_0</source_block_id><sink_block_id>pmt_cpp_start_share_0</sink_block_id><source_key>pmt_dict</source_key><sink_key>pmt::dict</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_share_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>pmt::mp</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_share_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>pmt::mp</source_key><sink_key>command</sink_key></connection>
</flow_graph>
